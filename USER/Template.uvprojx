# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\OLED;..\HARDWARE\TIMER;..\HARDWARE\AS608;..\HARDWARE\UART5;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\RTC;..\HARDWARE\FLASH;..\HARDWARE\RC522;..\HARDWARE\HC_SR501;..\HARDWARE\JQ8400;..\OTHERS;..\HARDWARE\TIMER;..\HARDWARE\REMOTE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group OLED
    ../OLED/: ascii.c china.c func.c logo.c oled.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/RC522/: rc522.c
    ../HARDWARE/HC_SR501/: HCSR501.c
    ../HARDWARE/JQ8400/: jq8400.c
    ../HARDWARE/REMOTE/: remote.c
  group OTHERS
    ../OTHERS/: pwd.c menu_option.c Lower_Power.c
